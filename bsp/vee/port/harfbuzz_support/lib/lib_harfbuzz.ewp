# IAR project lib_harfbuzz.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lib_harfbuzz.srec
  ILINK.IlinkOutputFile: lib_harfbuzz.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
